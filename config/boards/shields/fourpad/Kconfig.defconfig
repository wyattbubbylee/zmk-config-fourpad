## config/boards/shields/fourpad/Kconfig.defconfig
```kconfig
if SHIELD_FOURPAD

config ZMK_KEYBOARD_NAME
    default "Fourpad"

config USB_DEVICE_MANUFACTURER
    default "Waylon Walker"

endif
```
